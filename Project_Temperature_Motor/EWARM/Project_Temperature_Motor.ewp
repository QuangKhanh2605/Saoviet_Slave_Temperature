# IAR project Project_Temperature_Motor.ewp, settings and files
configuration Project_Temperature_Motor (ARM, debug)
  General.OGChipSelectEditMenu: STM32L072KB ST STM32L072KB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L072xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\user_app\user_app_common; ..\user_app\user_at_serial; ..\user_app\user_uart; ..\user_component\user_convert_variable; ..\user_component\user_mem; ..\user_component\user_mem\user_internal_mem; ..\user_eventdriven; ..\user_queue; ..\user_util; ..\user_timer; ..\user_trace; ..\user_app\user_app_modbus_rtu; ..\user_app\user_app_sensor
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project_Temperature_Motor.bin
  ILINK.IlinkOutputFile: Project_Temperature_Motor.out
  ILINK.IlinkIcfFile: stm32l072xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l072xx.s
  group Application/User/Core
    ../Core/Src/: dac.c dma.c gpio.c i2c.c iwdg.c main.c rtc.c stm32l0xx_hal_msp.c stm32l0xx_it.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dac.c stm32l0xx_hal_dac_ex.c stm32l0xx_hal_dma.c stm32l0xx_hal_exti.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_iwdg.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
  group user_app/user_app_common
    ../user_app/user_app_common/: user_app_comm.c user_app_comm.h user_define.h
  group user_app/user_app_modbus_rtu
    ../user_app/user_app_modbus_rtu/: user_app_modbus_rtu.c user_app_modbus_rtu.h user_app_rs485.c user_app_rs485.h user_rs485.c user_rs485.h
  group user_app/user_app_sensor
    ../user_app/user_app_sensor/: user_app_sensor.c user_app_sensor.h
  group user_app/user_at_serial
    ../user_app/user_at_serial/: user_at_serial.c user_at_serial.h
  group user_app/user_uart
    ../user_app/user_uart/: user_uart.c user_uart.h
  group user_component/user_convert_variable
    ../user_component/user_convert_variable/: user_convert_variable.c user_convert_variable.h
  group user_component/user_mem
    ../user_component/user_mem/: user_mem_comm.c user_mem_comm.h
  group user_component/user_mem/user_internal_mem
    ../user_component/user_mem/user_internal_mem/: user_internal_mem.c user_internal_mem.h
  group user_eventdriven
    ../user_eventdriven/: event_driven.c event_driven.h
  group user_queue
    ../user_queue/: queue_p.c queue_p.h
  group user_timer
    ../user_timer/: user_rtc.c user_rtc.h user_timer.c user_timer.h
  group user_trace
    ../user_trace/: user_adv_trace.c user_adv_trace.h
  group user_util
    ../user_util/: onchipflash.c onchipflash.h user_modbus_rtu.c user_modbus_rtu.h user_obis_sv.c user_obis_sv.h user_string.c user_string.h user_time.c user_time.h user_tiny_vsnprintf.c user_tiny_vsnprintf.h user_util.c user_util.h
