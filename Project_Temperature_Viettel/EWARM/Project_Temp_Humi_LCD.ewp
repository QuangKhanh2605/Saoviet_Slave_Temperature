# IAR project Project_Temp_Humi_LCD.ewp, settings and files
configuration Project_Temp_Humi_LCD (ARM, debug)
  General.OGChipSelectEditMenu: STM32L433RC ST STM32L433RC
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L433xx
  ICCARM.CCIncludePath2: ../Core/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc; ../Drivers/STM32L4xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../Drivers/CMSIS/Include; ..\user_app\user_app_common; ..\user_app\user_app_modbus_rtu; ..\user_app\user_app_sensor; ..\user_app\user_at_serial; ..\user_app\user_uart; ..\user_component\user_convert_variable; ..\user_component\user_mem; ..\user_component\user_mem\user_internal_mem; ..\user_eventdriven; ..\user_queue; ..\user_timer; ..\user_trace; ..\user_util; ..\user_app\user_app_sensor\user_hs300x; ..\user_app\user_app_interface
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Project_Temp_Humi_LCD.bin
  ILINK.IlinkOutputFile: Project_Temp_Humi_LCD.out
  ILINK.IlinkIcfFile: stm32l433xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l433xx.s
  group Application/User/Core
    ../Core/Src/: dma.c gpio.c i2c.c iwdg.c lcd.c main.c rtc.c stm32l4xx_hal_msp.c stm32l4xx_it.c usart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32l4xx.c
  group Drivers/STM32L4xx_HAL_Driver
    ../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_flash_ramfunc.c stm32l4xx_hal_gpio.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lcd.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c
  group user_app/user_app_common
    ../user_app/user_app_common/: user_app_comm.c user_app_comm.h user_define.h
  group user_app/user_app_interface
    ../user_app/user_app_interface/: button.c button.h lcd_display.c lcd_display.h lcd_segment.c lcd_segment.h user_com_seg.c user_com_seg.h
  group user_app/user_app_modbus_rtu
    ../user_app/user_app_modbus_rtu/: user_app_modbus_rtu.c user_app_modbus_rtu.h user_app_rs485.c user_app_rs485.h user_rs485.c user_rs485.h
  group user_app/user_app_sensor
    ../user_app/user_app_sensor/: user_app_sensor.c user_app_sensor.h
  group user_app/user_app_sensor/user_hs300x
    ../user_app/user_app_sensor/user_hs300x/: HS300x.c HS300x.h
  group user_app/user_at_serial
    ../user_app/user_at_serial/: user_at_serial.c user_at_serial.h
  group user_app/user_uart
    ../user_app/user_uart/: user_uart.c user_uart.h
  group user_component/user_convert_variable
    ../user_component/user_convert_variable/: user_convert_variable.c user_convert_variable.h
  group user_component/user_mem
    ../user_component/user_mem/: user_mem_comm.c user_mem_comm.h
  group user_component/user_mem/user_internal_mem
    ../user_component/user_mem/user_internal_mem/: user_internal_mem.c user_internal_mem.h
  group user_eventdriven
    ../user_eventdriven/: event_driven.c event_driven.h
  group user_queue
    ../user_queue/: queue_p.c queue_p.h
  group user_timer
    ../user_timer/: user_rtc.c user_rtc.h user_timer.c user_timer.h
  group user_trace
    ../user_trace/: user_adv_trace.c user_adv_trace.h
  group user_util
    ../user_util/: onchipflash.c onchipflash.h user_modbus_rtu.c user_modbus_rtu.h user_obis_sv.c user_obis_sv.h user_string.c user_string.h user_time.c user_time.h user_tiny_vsnprintf.c user_tiny_vsnprintf.h user_util.c user_util.h
