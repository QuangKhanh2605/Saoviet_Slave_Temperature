<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Project_Temp_Humi_LCD.ewp</path>
  </project>
  <batchBuild />
</workspace>
